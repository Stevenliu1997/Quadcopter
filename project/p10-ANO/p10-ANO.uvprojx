# Keil uVision project p10-ANO.uvprojx, settings and files
target Templates (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Templates
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\application;..\..\stdperiph\CMSIS\Device;..\..\stdperiph\CMSIS\Include;..\..\stdperiph\Driver\inc;..\..\ucosii;..\..\firmware\delay;..\..\firmware\FW6-motor-PWM;..\..\firmware\FW7-PWM-RCV;..\..\firmware\FW8-gpio-iic-mpu6050-rawdata
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group DEVICE
    ../../stdperiph/CMSIS/Device/: startup_stm32f411xe.s system_stm32f4xx.c
  group STDP
    ../../stdperiph/Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_conf.c
  group UCOS2
    ../../ucosii/: os_core.c os_cpu_a.asm os_cpu_c.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cpu_c_tick.c
  group APP
    ./application/: main.c EVAL_define.c USARTx_IRQHANDLER.c data_transfer.c Attitude.c gpio_hmc5883.c
  group FW
    ../../firmware/delay/: delay.c
    ../../firmware/FW6-motor-PWM/: motor-PWM.c
    ../../firmware/FW7-PWM-RCV/: PWM-RCV.c
    ../../firmware/FW8-gpio-iic-mpu6050-rawdata/: gpio_mpu6050.c gpio_i2c.c
